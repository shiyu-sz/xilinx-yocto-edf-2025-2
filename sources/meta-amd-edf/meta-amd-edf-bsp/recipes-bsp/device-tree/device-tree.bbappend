require device-tree-local-archive.inc
require hdmi-display.inc
require ov2640-camera.inc

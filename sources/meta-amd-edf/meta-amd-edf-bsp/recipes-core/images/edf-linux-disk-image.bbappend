IMAGE_INSTALL:append:zynq-xc7z020-custom = " edf-fb-test"
IMAGE_INSTALL:append:zynq-xc7z020-custom = " v4l-utils media-ctl"
IMAGE_INSTALL:append:zynq-xc7z020-custom = " lvgl lvgl-demo-fb"

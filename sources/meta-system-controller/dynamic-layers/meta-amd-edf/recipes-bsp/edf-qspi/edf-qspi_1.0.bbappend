COMPATIBLE_MACHINE:zynqmp-k24-sc-sdt-base = "${MACHINE}"
COMPATIBLE_MACHINE:zynqmp-k26-sc-sdt-base = "${MACHINE}"
